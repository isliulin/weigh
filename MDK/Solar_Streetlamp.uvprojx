# Keil uVision project Solar_Streetlamp.uvprojx, settings and files
target Mode (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HexFile +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Bsp\inc;..\CM3\inc;..\STM32F10x_StdPeriph_Lib\inc;..\User\inc;..\STemWin\Config;..\STemWin\inc;..\Demo;..\Actuator\Inc;..\App\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/src/: main.c stm32f10x_it.c
  group App
    ../App/src/: communication.c weigh.c modbus.c bsp_eeprom_24xx.c uc1689uGui.c
  group Bsp
    ../Bsp/src/: bsp.c uc1689u.c bsp_i2c_gpio.c mbcrc.c key.c
  group CM3
    ../CM3/src/: core_cm3.c system_stm32f10x.c
  group STM32F10x_StdPeriph_Lib
    ../STM32F10x_StdPeriph_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../CM3/startup/: startup_stm32f10x_hd.s
